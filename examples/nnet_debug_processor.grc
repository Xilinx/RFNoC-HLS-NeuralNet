<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>nnet_debug_processor</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip_addr</value></param>
<param><key>value</key><value>"10.10.0.112"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100*10000</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=e3x0</value></param>
<param><key>dev_args</key><value>args</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>modrec_rfnoc_output.s16</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>modrec_data_input.s16</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>ex2_binary_validation_data.s16</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_1</value></param>
<param><key>ipaddr</key><value>ip_addr</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1000</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fpgannet_exmodrec</key>
<param><key>id</key><value>fpgannet_exmodrec_0</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_exmodrec</value></param>
<param><key>grvlenin</key><value>1</value></param>
<param><key>grvlenout</key><value>1</value></param>
<param><key>type</key><value>item32</value></param>
<param><key>spp</key><value>640</value></param>
<param><key>block_index</key><value>-1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>item32</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_fifo_0_0</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>block_index</key><value>1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_fifo_loopback</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>item32</value></param>
</block>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_udp_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpgannet_exmodrec_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fpgannet_exmodrec_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0</source_block_id><sink_block_id>fpgannet_exmodrec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_fifo_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_fifo_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
